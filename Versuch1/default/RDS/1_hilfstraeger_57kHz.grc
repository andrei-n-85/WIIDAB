<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_conjugate_cc</key>
<param><key>id</key><value>gr_conjugate_cc_0</value></param>
</block>
<block>
<key>gr_delay</key>
<param><key>id</key><value>gr_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sampling Rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(1,0,1,1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>80</value></param>
</block>
<block>
<key>gr_complex_to_arg</key>
<param><key>id</key><value>gr_complex_to_arg_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain_38k</value></param>
<param><key>label</key><value>Gain (38kHz-Traeger)</value></param>
<param><key>value</key><value>39</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(0,2,1,1)</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>low_cutoff_freq</key><value>38e3-15000</value></param>
<param><key>high_cutoff_freq</key><value>38e3+15000</value></param>
<param><key>width</key><value>10000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>gr_iir_filter_ffd</key>
<param><key>id</key><value>gr_iir_filter_ffd_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fftaps</key><value>(1.0/(1+tau*2*samp_rate), 1.0/(1+tau*2*samp_rate))</value></param>
<param><key>fbtaps</key><value>(1, -(1-tau*2*samp_rate)/(1+tau*2*samp_rate))</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>vol_r/100*3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>vol_l/100*3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vol_r</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Volume R</value></param>
<param><key>value</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vol_l</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Volume L</value></param>
<param><key>value</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
</block>
<block>
<key>gr_iir_filter_ffd</key>
<param><key>id</key><value>gr_iir_filter_ffd_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fftaps</key><value>(1.0/(1+tau*2*samp_rate), 1.0/(1+tau*2*samp_rate))</value></param>
<param><key>fbtaps</key><value>(1, -(1-tau*2*samp_rate)/(1+tau*2*samp_rate))</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>stereo</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>25</value></param>
<param><key>gain</key><value>120</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>25</value></param>
<param><key>gain</key><value>120</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_2_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>interp</key><value>9</value></param>
<param><key>gain</key><value>38</value></param>
<param><key>samp_rate</key><value>samp_rate/25</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_2_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>interp</key><value>7</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9/8*7/8</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9/8*7</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>interp</key><value>7</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9/8</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_2_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>interp</key><value>7</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9/8*7/8</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9/8*7</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>interp</key><value>7</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9/8</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>interp</key><value>9</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9/8*7/8*7</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/25*9/8*7/8*7</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>gr_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>gain_38k</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>low_cutoff_freq</key><value>38e3-1000</value></param>
<param><key>high_cutoff_freq</key><value>38e3+1000</value></param>
<param><key>width</key><value>5000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>6</value></param>
<param><key>interp</key><value>8</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>60e3</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>gain_38k</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>low_cutoff_freq</key><value>57e3-1000</value></param>
<param><key>high_cutoff_freq</key><value>57e3+1000</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Audio Scope L</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>20</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>20</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Audio Scope R</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook_0</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['57kHz-Hilfstraeger (FFT)','Pilotton (FFT)','57kHz-Hilfstraeger (Scope)','Pilotton (Scope)']</value></param>
<param><key>grid_pos</key><value>(3,0,1,3)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequenz (UKW)</value></param>
<param><key>value</key><value>93.3e6</value></param>
<param><key>min</key><value>87.5e6</value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>num_steps</key><value>205</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(0,0,1,1)</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>low_cutoff_freq</key><value>19e3-500</value></param>
<param><key>high_cutoff_freq</key><value>19e3+500</value></param>
<param><key>width</key><value>5000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>MPX-Signal</value></param>
<param><key>samp_rate</key><value>samp_rate/6</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>5</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>6</value></param>
<param><key>interp</key><value>8</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>60e3</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Pilotton (Scope)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>notebook_0,3</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Pilotton (FFT)</value></param>
<param><key>samp_rate</key><value>samp_rate/6</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>6</value></param>
<param><key>interp</key><value>8</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>60e3</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>57kHz-Hilfstraeger (FFT)</value></param>
<param><key>samp_rate</key><value>samp_rate/6</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>57kHz-Hilfstraeger (Scope)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>notebook_0,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>b_signal</value></param>
<param><key>label</key><value>Signalbandbreite</value></param>
<param><key>value</key><value>390e3</value></param>
<param><key>min</key><value>1e3</value></param>
<param><key>max</key><value>400e3</value></param>
<param><key>num_steps</key><value>399</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(1,1,1,1)</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>b_signal</value></param>
<param><key>width</key><value>10000</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tau</value></param>
<param><key>label</key><value>Zeitkonstante (Tau)</value></param>
<param><key>value</key><value>50e-6</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100e-6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value></value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_simple_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>rx_gain</value></param>
<param><key>side</key><value>B</value></param>
<param><key>rx_ant</key><value>RXA</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>Receiver Gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>stereo</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Stereo</value></param>
<param><key>value</key><value>1</value></param>
<param><key>true</key><value>1</value></param>
<param><key>false</key><value>0</value></param>
<param><key>grid_pos</key><value>2,2,1,1</value></param>
</block>
<connection><source_block_id>usrp_simple_source_x_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0</source_block_id><sink_block_id>gr_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>gr_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_conjugate_cc_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_arg_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_1</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>gr_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_2</source_block_id><sink_block_id>gr_iir_filter_ffd_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_arg_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_arg_0</source_block_id><sink_block_id>gr_iir_filter_ffd_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_1</source_block_id><sink_block_id>gr_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_arg_0</source_block_id><sink_block_id>band_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_iir_filter_ffd_1</source_block_id><sink_block_id>low_pass_filter_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_2</source_block_id><sink_block_id>low_pass_filter_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_iir_filter_ffd_1_0</source_block_id><sink_block_id>gr_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_1_0</source_block_id><sink_block_id>low_pass_filter_2_0_2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_2_2</source_block_id><sink_block_id>low_pass_filter_2_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_0_1</source_block_id><sink_block_id>low_pass_filter_2_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_2_0_0</source_block_id><sink_block_id>low_pass_filter_2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_0_0_0</source_block_id><sink_block_id>low_pass_filter_2_0_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_2_1_0</source_block_id><sink_block_id>low_pass_filter_2_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_2_1</source_block_id><sink_block_id>low_pass_filter_2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_0_0</source_block_id><sink_block_id>low_pass_filter_2_0_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_2_0</source_block_id><sink_block_id>low_pass_filter_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_0</source_block_id><sink_block_id>low_pass_filter_2_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_2</source_block_id><sink_block_id>low_pass_filter_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_1</source_block_id><sink_block_id>low_pass_filter_2_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_fftsink2_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>wxgui_fftsink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_1_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_1</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_1_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_1</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_3</source_block_id><sink_block_id>band_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>gr_multiply_xx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>low_pass_filter_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_1</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0</source_block_id><sink_block_id>low_pass_filter_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>wxgui_scopesink2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
